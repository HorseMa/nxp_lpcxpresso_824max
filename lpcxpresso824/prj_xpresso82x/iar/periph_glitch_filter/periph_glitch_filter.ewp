# IAR project periph_glitch_filter.ewp, settings and files
configuration iflash_nxp_lpcxpresso_824 (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../brd_xpresso824/inc; ../../../chip_82x/inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: periph_glitch_filter.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../examples_82x/periph_glitch_filter/src/: glitch_filter.c
    ../../../chip_82x/startup/: iar_startup_lpc82x.s sysinit.c
    ../../../examples_82x/periph_glitch_filter/: readme.txt
  group lib
    ../lib_board_lpcxpresso824/iar_output/Exe/: board_nxp_lpcxpresso_824.a
    ../lib_chip_8xx/iar_output/Exe/: chip_8xx_lib.a
