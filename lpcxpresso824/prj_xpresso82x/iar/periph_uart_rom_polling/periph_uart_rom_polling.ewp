# IAR project periph_uart_rom_polling.ewp, settings and files
configuration iflash_nxp_lpcxpresso_824 (ARM)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pe161, Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../brd_xpresso824/inc; ../../../chip_82x/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_8xx\nxp_lpcxpresso_824; ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_8xx\config
  OBJCOPY.OOCOutputFile: periph_uart_rom_polling.bin
  ILINK.IlinkOutputFile: periph_uart_rom_polling.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group example
    ../../../chip_82x/startup/: iar_startup_lpc82x.s sysinit.c
    ../../../examples_82x/periph_uart/: readme.txt
    ../../../examples_82x/periph_uart_rom_polling/src/: uart_rom_polling.c
  group lib
    ../lib_board_lpcxpresso824/iar_output/Exe/: board_nxp_lpcxpresso_824.a
    ../lib_chip_8xx/iar_output/Exe/: chip_8xx_lib.a
