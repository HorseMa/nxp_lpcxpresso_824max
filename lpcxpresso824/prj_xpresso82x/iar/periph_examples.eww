<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lib_chip_8xx\lib_chip_8xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lib_board_lpcxpresso824\lib_board_lpcxpresso824.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_acmp\periph_acmp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_bod\periph_bod.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_blinky\periph_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_clkout\periph_clkout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_crc\periph_crc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_flashiap\periph_flashiap.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_glitch_filter\periph_glitch_filter.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_gpio\periph_gpio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2c_rom_interrupt\periph_i2c_rom_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2c_rom_polling\periph_i2c_rom_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2c_rom_slave_interrupt\periph_i2c_rom_slave_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cm_interrupt\periph_i2cm_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cm_polling\periph_i2cm_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_i2cs_interrupt\periph_i2cs_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pinint\periph_pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_mrt\periph_mrt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_pll_tab\periph_pll_tab.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_sct\periph_sct.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_sct_pwm\periph_sct_pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_spi\periph_spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_spi_sm_int\periph_spi_sm_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_systick\periph_systick.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart\periph_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart_rb\periph_uart_rb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart_rom_int\periph_uart_rom_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_uart_rom_polling\periph_uart_rom_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_wkt\periph_wkt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph_wwdt\periph_wwdt.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lib_board_lpcxpresso824</project>
        <configuration>nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>lib_chip_8xx</project>
        <configuration>chip_8xx_lib</configuration>
      </member>
      <member>
        <project>periph_acmp</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_blinky</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_bod</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_clkout</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_crc</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_flashiap</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_glitch_filter</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_gpio</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_i2c_rom_interrupt</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_i2c_rom_polling</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_i2c_rom_slave_interrupt</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_i2cm_interrupt</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_i2cm_polling</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_i2cs_interrupt</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_mrt</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_pinint</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_sct</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_sct_pwm</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_spi</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_spi_sm_int</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_systick</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_uart_rb</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_uart_rom_int</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_uart_rom_polling</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_wkt</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_wwdt</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_pll_tab</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
      <member>
        <project>periph_uart</project>
        <configuration>iflash_nxp_lpcxpresso_824</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


