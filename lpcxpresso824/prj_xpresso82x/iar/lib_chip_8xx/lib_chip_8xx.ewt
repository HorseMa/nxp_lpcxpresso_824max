<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>chip_8xx_lib</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>chip_8xx</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\acmp_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\chip_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\clock_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\crc_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\gpio_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\i2c_common_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\i2cm_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\i2cs_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\iap.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\iocon_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\irc_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\pinint_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\pmu_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\ring_buffer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\sct_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\sct_pwm_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\spi_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\spim_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\spis_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\stopwatch_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\swm_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\syscon_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\sysinit_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\uart_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\wkt_8xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\src\wwdt_8xx.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\..\chip_82x\startup\iar_startup_lpc82x.s</name>
  </file>
</project>


