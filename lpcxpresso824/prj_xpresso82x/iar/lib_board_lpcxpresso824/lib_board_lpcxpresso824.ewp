# IAR project lib_board_lpcxpresso824.ewp, settings and files
configuration nxp_lpcxpresso_824 (ARM)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS; DEBUG_ENABLE; DEBUG_UART=LPC_USART0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../brd_xpresso824/inc; ../../../chip_82x/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: lib_board_lpcxpresso824.out
  group board_nxp_lpcxpresso_824
    ../../../brd_xpresso824/src/: board.c board_sysinit.c
