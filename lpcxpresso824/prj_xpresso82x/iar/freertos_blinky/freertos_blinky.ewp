# IAR project freertos_blinky.ewp, settings and files
configuration iflash_nxp_lpcxpresso_812 (ARM)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0PLUS; USE_BAND_433
  ICCARM.CCDiagSuppress: Pe161, Pa050, Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../brd_xpresso824/inc; ../../../chip_82x/inc; ..\..\..\..\freertos\freertos\Source\include; ..\..\..\..\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\freertos\freertoslpc; ..\..\..\examples_82x\freertos_blinky\inc; ..\..\..\..\lorawan; ..\..\..\..\lorawan\radio; ..\..\..\..\lorawan\radio\sx1276; ..\..\..\..\lorawan\boards\Bleeper-76; ..\..\..\..\lorawan\boards\mcu\stm32; ..\..\..\..\lorawan\system\crypto; ..\..\..\..\lorawan\system\; ..\..\..\..\lorawan\mac
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M0PLUS
  AARM.AUserIncludes: $PROJ_DIR$; ../../../brd_xpresso824/inc; ../../../chip_82x/inc; ..\..\..\examples_82x\freertos\freertos\Source\include; ..\..\..\examples_82x\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\examples_82x\freertos\freertoslpc; ..\..\..\examples_82x\freertos_blinky\inc
  OBJCOPY.OOCOutputFile: freertos_blinky.hex
  ILINK.IlinkOutputFile: freertos_blinky.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ClassA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CORE_M0PLUS; USE_BAND_433; DEBUG_UART=LPC_USART1
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../../../brd_xpresso824/inc; ../../../chip_82x/inc; ..\..\..\..\freertos\freertos\Source\include; ..\..\..\..\freertos\freertos\Source\portable\IAR\ARM_CM0; ..\..\..\..\freertos\freertoslpc; ..\..\..\examples_82x\freertos_blinky\inc; ..\..\..\..\lorawan; ..\..\..\..\lorawan\radio; ..\..\..\..\lorawan\radio\sx1276; ..\..\..\..\lorawan\boards\mcu\stm32; ..\..\..\..\lorawan\system\crypto; ..\..\..\..\lorawan\mac; ..\..\..\..\lorawan\mac\region; ..\..\..\..\lorawan\apps\LoRaMac\classA\SensorNode; ..\..\..\..\lorawan\boards\SensorNode; ..\..\..\..\lorawan\atcmd
  ICCARM.CCOptLevel: 2
configuration ClassB (ARM)
  as the first configuration, except:
configuration ClassC (ARM)
  as the first configuration, except:
  group example
    ../../../examples_82x/freertos_blinky/src/: freertos_blinky.c
    ../../../chip_82x/startup/: iar_startup_lpc82x.s sysinit.c
    ../../../../lorawan/apps/LoRaMac/classA/SensorNode/: main.c
    ../../../../lorawan/apps/LoRaMac/classA/Bleeper-76/: mainA.c
    ../../../../lorawan/apps/LoRaMac/classB/Bleeper-76/: mainB.c
    ../../../../lorawan/apps/LoRaMac/classC/Bleeper-76/: mainC.c
    ../../../examples_82x/periph_wwdt/: readme.txt
  group FreeRTOS
    ../../../../freertos/freertos/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../freertos/freertos/Source/portable/MemMang/: heap_2.c
    ../../../../freertos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group lib
    ../lib_board_lpcxpresso824/iar_output/Exe/: board_nxp_lpcxpresso_824.a
    ../lib_chip_8xx/iar_output/Exe/: chip_8xx_lib.a
  group lorawan/atcmd
    ../../../../lorawan/atcmd/: buffer.c frame.c hex.c modem.c modem.h usart.c
  group lorawan/hal
    ../../../../lorawan/system/crypto/: aes.c aes.h cmac.c cmac.h
    ../../../../lorawan/boards/SensorNode/: sx1276-board.c
    ../../../../lorawan/system/: timer.c
    ../../../../lorawan/boards/mcu/stm32/: utilities.c
  group lorawan/mac
    ../../../../lorawan/mac/: LoRaMac.c LoRaMac.h LoRaMacCrypto.c LoRaMacCrypto.h
    ../../../../lorawan/mac/region/: Region.c RegionCN470.c RegionCommon.c
  group lorawan/radio
    ../../../../lorawan/radio/: radio.h
    ../../../../lorawan/radio/sx1276/: sx1276.c sx1276.h sx1276Regs-Fsk.h sx1276Regs-LoRa.h
