<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>iflash_nxp_lpcxpresso_812</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>ClassA</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>ClassB</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>ClassC</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>example</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\examples_82x\freertos_blinky\src\freertos_blinky.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\startup\iar_startup_lpc82x.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lorawan\apps\LoRaMac\classA\SensorNode\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lorawan\apps\LoRaMac\classA\Bleeper-76\mainA.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lorawan\apps\LoRaMac\classB\Bleeper-76\mainB.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\lorawan\apps\LoRaMac\classC\Bleeper-76\mainC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\examples_82x\periph_wwdt\readme.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\chip_82x\startup\sysinit.c</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertos\Source\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertoslpc\FreeRTOSCommonHooks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertos\Source\portable\MemMang\heap_2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertos\Source\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertos\Source\portable\IAR\ARM_CM0\port.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertos\Source\portable\IAR\ARM_CM0\portasm.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertos\Source\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertos\Source\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\freertos\freertos\Source\timers.c</name>
    </file>
  </group>
  <group>
    <name>lib</name>
    <file>
      <name>$PROJ_DIR$\..\lib_board_lpcxpresso824\iar_output\Exe\board_nxp_lpcxpresso_824.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lib_chip_8xx\iar_output\Exe\chip_8xx_lib.a</name>
    </file>
  </group>
  <group>
    <name>lorawan</name>
    <group>
      <name>atcmd</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\atcmd\buffer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\atcmd\frame.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\atcmd\hex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\atcmd\modem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\atcmd\modem.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\atcmd\queue_IBM.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\atcmd\usart.c</name>
      </file>
    </group>
    <group>
      <name>hal</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\system\crypto\aes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\system\crypto\aes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\system\crypto\cmac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\system\crypto\cmac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\boards\SensorNode\rtc-board.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\boards\SensorNode\sx1276-board.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\system\timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\boards\mcu\stm32\utilities.c</name>
      </file>
    </group>
    <group>
      <name>mac</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\mac\LoRaMac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\mac\LoRaMac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\mac\LoRaMacCrypto.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\mac\LoRaMacCrypto.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\mac\region\Region.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\mac\region\RegionCN470.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\mac\region\RegionCommon.c</name>
      </file>
    </group>
    <group>
      <name>radio</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\radio\radio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\radio\sx1276\sx1276.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\radio\sx1276\sx1276.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\radio\sx1276\sx1276Regs-Fsk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\lorawan\radio\sx1276\sx1276Regs-LoRa.h</name>
      </file>
    </group>
  </group>
</project>


