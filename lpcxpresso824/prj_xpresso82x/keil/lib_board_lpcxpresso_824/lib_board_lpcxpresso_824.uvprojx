# Keil uVision project lib_board_lpcxpresso_824.uvprojx, settings and files
target lib_board_lpcxpresso_lpc824 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_board_lpcxpresso_lpc824 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\chip_82x\inc;..\..\..\brd_xpresso824\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ../../../brd_xpresso824/src/: board.c board_sysinit.c
