# Keil uVision project periph_i2c_rom_slave_interrupt.uvprojx, settings and files
target iflash_nxp_lpcxpresso_824 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: i2c_rom_slave_interrupt
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS DEBUG_ENABLE
  c include: ..\..\..\chip_82x\inc;..\..\..\brd_xpresso824\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ../../../chip_82x/startup/: sysinit.c keil_startup_lpc82x.s
    ../../../examples_82x/periph_i2c_rom_slave_interrupt/src/: i2c_rom_slave_interrupt.c
    ../../../examples_82x/periph_i2c_rom_slave_interrupt/: readme.txt
  group lib
    ../lib_board_lpcxpresso_824/keil_output/: lib_board_lpcxpresso_lpc824.lib
    ../lib_chip_8xx/keil_output/: lib_chip_82x.lib
