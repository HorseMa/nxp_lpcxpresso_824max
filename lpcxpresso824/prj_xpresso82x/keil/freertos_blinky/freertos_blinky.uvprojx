# Keil uVision project freertos_blinky.uvprojx, settings and files
target iflash_nxp_lpcxpresso_824 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: freertos_blinky
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\examples_82x\freertos_blinky\inc;..\..\..\chip_82x\inc;..\..\..\brd_xpresso824\inc;..\..\..\..\freertos\freertos\Source\include;..\..\..\..\freertos\freertos\Source\portable\RVDS\ARM_CM0;..\..\..\..\freertos\freertoslpc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group example
    ../../../chip_82x/startup/: sysinit.c keil_startup_lpc82x.s
    ../../../examples_82x/freertos_blinky/src/: freertos_blinky.c
    ../../../examples_82x/freertos_blinky/: readme.txt
  group lib
    ../lib_board_lpcxpresso_824/keil_output/: lib_board_lpcxpresso_lpc824.lib
    ../lib_chip_8xx/keil_output/: lib_chip_82x.lib
  group FreeRTOS
    ../../../../freertos/freertos/Source/: tasks.c queue.c list.c croutine.c timers.c
    ../../../../freertos/freertos/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../freertos/freertos/Source/portable/MemMang/: heap_3.c
