# Keil uVision project lib_chip_8xx.uvprojx, settings and files
target lib_chip_82x (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_chip_82x (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\..\..\chip_82x\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ../../../chip_82x/src/: acmp_8xx.c adc_8xx.c clock_8xx.c crc_8xx.c dma_8xx.c gpio_8xx.c iocon_8xx.c irc_8xx.c pinint_8xx.c pmu_8xx.c sct_8xx.c sct_pwm_8xx.c spi_8xx.c swm_8xx.c syscon_8xx.c uart_8xx.c wkt_8xx.c wwdt_8xx.c chip_8xx.c sysinit_8xx.c ring_buffer.c iap.c stopwatch_8xx.c i2c_common_8xx.c i2cm_8xx.c i2cs_8xx.c spim_8xx.c spis_8xx.c
